# Keil uVision project lib_lpc_chip_112x.uvproj, settings and files
target chip_112x_lib (ARM-ADS)
  device: LPC1125 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lib_lpc_chip_112x (library)
  c flags: Optim=4 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\software\lpc_core\lpc_chip\chip_112x;..\..\..\..\software\lpc_core\lpc_chip\chip_112x\config_112x;..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\software\CMSIS\CMSIS\Include
  asm include: ..\..\..\..\software\lpc_core\lpc_chip\chip_112x;..\..\..\..\software\lpc_core\lpc_chip\chip_112x\config_1125;..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\software\CMSIS
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group csp
    ../chip_common/: ring_buffer.c iap.c
    ./: adc_112x.c chip_112x.c clock_112x.c gpio_112x.c i2c_112x.c i2cm_112x.c iocon_112x.c pmu_112x.c ssp_112x.c syscon_112x.c sysinit_112x.c timer_112x.c uart_112x.c wwdt_112x.c
