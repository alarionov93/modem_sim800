# IAR project lib_lpc_chip_112x.ewp, settings and files
configuration iflash_nxp_lpcxpresso_112x (ARM, debug)
  General.OGChipSelectEditMenu: LPC1125 NXP LPC1125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; config_112x; ../chip_common; ../../../CMSIS/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_112x.out
  group csp
    ./: adc_112x.c chip_112x.c clock_112x.c gpio_112x.c i2c_112x.c i2cm_112x.c iocon_112x.c pmu_112x.c romdiv_112x.c ssp_112x.c syscon_112x.c sysinit_112x.c timer_112x.c uart_112x.c wwdt_112x.c
    ../chip_common/: iap.c ring_buffer.c
