# Keil uVision project modem.uvproj, settings and files
target debug (ARM-ADS)
  device: LPC1125 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: modem
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CORE_M0,NO_BOARD_LIB
  c include: .\src;.\src\lpc_chip\chip_112x;.\src\lpc_chip\chip_common;.\src\lpc_chip\chip_112x\config_112x
  asm define: CORE_M0
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group sys
    ./src/: init.c sysinit.c main.c keil_startup_lpc112x.s modem.c crc.c flash.c modbus.c
  group chip
    ./src/lpc_chip/chip_112x/: chip_112x.c uart_112x.c gpio_112x.c clock_112x.c sysinit_112x.c syscon_112x.c
    ./src/lpc_chip/chip_common/: ring_buffer.c
